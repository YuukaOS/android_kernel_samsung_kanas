## arch/arm/hotplug/Kconfig
```kconfig
# AutoSMP hotplug
source "arch/arm/hotplug/autosmp/Kconfig"

# Intelli_plug
source "arch/arm/hotplug/intelli_plug/Kconfig"
```
